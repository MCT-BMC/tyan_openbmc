FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"
SRC_URI_append = " file://sol-pattern.override.yml"
