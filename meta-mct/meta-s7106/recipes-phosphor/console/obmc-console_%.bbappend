FILESEXTRAPATHS_prepend_s7106 := "${THISDIR}/${PN}:"
OBMC_CONSOLE_HOST_TTY = "ttyS2"
