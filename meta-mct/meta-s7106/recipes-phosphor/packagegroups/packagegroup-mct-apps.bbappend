RDEPENDS_${PN}-chassis_remove += "obmc-button-reset"