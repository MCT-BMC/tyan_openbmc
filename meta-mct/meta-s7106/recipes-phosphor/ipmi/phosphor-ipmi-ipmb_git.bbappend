FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-s7106-patch-ipmbbridge-to-assign-correct-ME-bus-numb.patch"

