PHOSPHOR_DBUS_MONITOR_CONFIGS_append = "s8036-event-policy-native"
