FILESEXTRAPATHS_prepend_s8036 := "${THISDIR}/${PN}:"
