FILESEXTRAPATHS_prepend_s8030 := "${THISDIR}/${PN}:"
