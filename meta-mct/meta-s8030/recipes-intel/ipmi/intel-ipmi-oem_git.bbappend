FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-s8030-update-uid-chassis-command-behavior.patch"

