LIC_FILES_CHKSUM = "file://LICENSE.MIT;md5=dd0607f896f392c8b7d0290a676efc24"

SRCREV = "db78ac1d7716f56fc9f1b030b715f872f93964e4"