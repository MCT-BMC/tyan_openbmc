FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"
SRC_URI_append = " file://timeowner-host-no-ntp.override.yml"
