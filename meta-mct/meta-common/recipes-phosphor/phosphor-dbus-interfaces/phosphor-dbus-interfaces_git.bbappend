FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Feature-Add-TimerUse-property-in-watchdog-dbus-inter.patch"

