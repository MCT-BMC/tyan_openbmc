RDEPENDS_${PN}-sensors += " phosphor-hwmon"
