FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-MCT-Add-virtual-sensor-support.patch"

