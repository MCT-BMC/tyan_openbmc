FILESEXTRAPATHS_prepend := "${THISDIR}/pytools:"

SRC_URI += "file://0001-obmc-pydevtools-pytools-gpioutil.patch \
           "

