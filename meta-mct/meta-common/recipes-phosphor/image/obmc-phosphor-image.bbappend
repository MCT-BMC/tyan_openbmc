OBMC_IMAGE_EXTRA_INSTALL_append = " phosphor-ipmi-tool sync-pch-rtc"
