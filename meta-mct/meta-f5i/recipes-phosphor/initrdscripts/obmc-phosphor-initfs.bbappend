FILESEXTRAPATHS_prepend_f5i := "${THISDIR}/${PN}:"
