RDEPENDS_${PN}-chassis_remove += " \
                                    obmc-control-chassis \
                                    obmc-op-control-power \
                                  "
