FILESEXTRAPATHS_prepend_s5549 := "${THISDIR}/${PN}:"
