FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Implement-the-clear-bios-post-code-feature-for-host-.patch"

