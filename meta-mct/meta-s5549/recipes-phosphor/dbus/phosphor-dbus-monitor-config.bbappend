PHOSPHOR_DBUS_MONITOR_CONFIGS_append = "mct-event-policy-native"
