FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Force-baseboard-FRU-to-ID0.patch \
            "

