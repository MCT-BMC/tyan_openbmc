FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-new_signal-and-extend-set_property-methods-to-db.patch"

